# Keil uVision project m482sida_main.uvproj, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M482SIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: m482sida_main
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ../bin/water_main.bin ../KEIL/obj/m482sida_main.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\Device\Nuvoton\M480\Include;..\Device\Nuvoton\M480\Source\ARM;..\Device\Nuvoton\M480\Source\GCC;..\Device\Nuvoton\M480\Source\IAR;..\Device;..\Device\Nuvoton;..\Device\Nuvoton\M480;..\FreeRTOS\Source\include;..\FreeRTOS;..\..\m482sidae;..\StdDriver\src;..\StdDriver\inc;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\FreeRTOS\Demo\Common\include;..\hardware;..\4G;..\swipe;..\global;..\rtc;..\adc;..\control;..\log;..\12864_serial_zk;..\qr_code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group System
    ../Device/Nuvoton/M480/Source/ARM/: startup_M480.s
    ../Device/Nuvoton/M480/Source/: system_M480.c
  group FreeRTOS files
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group lib
    ../StdDriver/src/: rtc.c clk.c gpio.c sys.c uart.c scuart.c pdma.c sc.c eadc.c epwm.c fmc.c wdt.c timer.c
  group hardware
    ../hardware/: hardware.c led_gpio.c sys_clock.c dma.c isp_program.c wacth_dog.c delay.c key.c
  group 4G
    ../4G/: uart7_config.c 4G.c commucation.c pack_load.c pack_temp.c pack_onlink_trade.c pack_state_changge.c
  group swipe
    ../swipe/: swipe_led.c uart1_config.c uart2_config.c uart3_config.c uart4_config.c uart5_config.c uart6_config.c swipe.c task_swipe.c
  group global
    ../: main.c
    ../global/: msg.c global.c hook.c fsm.c user_config.h readme.txt
  group rtc
    ../rtc/: user_rtc.c
  group adc
    ../adc/: adc.c temp.c
  group control
    ../hardware/: tap_set.c
    ../control/: epwm_driver.c gpio_int.c
  group log
    ../StdDriver/src/: retarget.c
    ../log/: uart0_log.c log_interface_cmd.c
  group 12864_serial_zk
    ../12864_serial_zk/: 12864_driver.c display.c
  group qr_code
    ../qr_code/: QR_Encode.c QRCODE_business_layer.c
